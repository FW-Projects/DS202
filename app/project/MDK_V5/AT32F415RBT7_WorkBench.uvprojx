# Keil uVision project AT32F415RBT7_WorkBench.uvprojx, settings and files
target AT32F415RBT7_WorkBench (6230000::V6.23::ARMCLANG)
  device: -AT32F415RBT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.1.6
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: AT32F415RBT7_WorkBench +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  AfterMake: C:\Users\Administrator\Desktop\keil5_disp_size_bar.exe
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: AT32F415RBT7,USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\system;..\app;..\device
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: main.c at32f415_wk_config.c at32f415_int.c wk_system.c wk_debug.c wk_usart.c iap.c wk_gpio.c wk_wdt.c wk_crc.c wk_adc.c wk_tmr.c wk_dma.c
    ../device/: userconfig.h
  group firmware
    ../../libraries/drivers/src/: at32f415_crm.c at32f415_debug.c at32f415_flash.c at32f415_gpio.c at32f415_misc.c at32f415_pwc.c at32f415_usart.c at32f415_tmr.c at32f415_adc.c at32f415_spi.c at32f415_dma.c at32f415_exint.c at32f415_wdt.c at32f415_crc.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f415.c
    ./: startup_at32f415.s
  group system
    ../system/: tmt.c
  group app
    ../app/: PC_comm_handle.c beep_handle.c ec11_handle.c flash_handle.c key_handle.c led_handle.c output_handle.c PID_handle.c DS201_handle.c
  group device
    ../device/: util_queue.c at32_Usart.c adc_filter.c beep.c EncoderEC11.c flash.c key.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Event Recorder 1.1.0, CMSIS-View:Event Recorder 1.6.0, CMSIS:CORE 6.1.1, Utilities:perf_counter:Core 2.4.0
